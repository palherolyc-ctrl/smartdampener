# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target taget (6240000::V6.24::ARMCLANG)
  device: PHY6222 Generic
  pack: Keil.PHY62xx.1.1.0
  cpu: IRAM(0x1FFFC000,0x00002000) IROM(0x11000000,0x00100000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: simpleBlePeripheral +hex
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  AfterMake: fromelf -c -a -d -e -v -o simpleBlePeripheral.asm ./Objects/simpleBlePeripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP CFG_HCLK_DYNAMIC_CHANGE=0 DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\Profiles\ota_app;..\..\..\components\Profiles\DevInfo;..\..\..\components\Profiles\SimpleProfile;..\..\..\components\Profiles\Roles;.\source;..\..\..\components\libraries\crc16;..\..\..\components\driver\watchdog;..\..\..\components\driver\clock;..\..\..\components\arch\cm0;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\gpio;..\..\..\components\driver\timer;..\..\..\misc;..\..\..\components\driver\log;..\..\..\components\libraries\cliface;..\..\..\components\driver\key;..\..\..\components\driver\pwm;..\..\..\components\driver\flash;..\..\..\components\libraries\fs;..\..\..\components\driver\led_light;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\inc;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\ble\controller;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\osal\include;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\ble\include;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\ble\hci;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\ble\host;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\profiles\ota_app;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\profiles\DevInfo;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\profiles\SimpleProfile;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\profiles\Roles;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\libraries\crc16;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\watchdog;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\clock;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\arch\cm0;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\pwrmgr;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\uart;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\gpio;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\timer;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\misc;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\log;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\libraries\cli;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\key;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\pwm;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\flash;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\libraries\fs;..\..\release_bbb_sdk-PHY62XX_SDK_3.1.5\components\driver\led_light
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x100000
  memory RVCT9: RAM 0x1fffc000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: D:\\智能网球避震器\\固件\\smartdampener-minimax\\simpleBlePeripheral\\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group driver
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/uart/: uart.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/clock/: clock.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/gpio/: gpio.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/timer/: timer.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/watchdog/: watchdog.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/pwrmgr/: pwrmgr.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/log/: my_printf.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/key/: key.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/pwm/: pwm.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/osal/snv/: osal_snv.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/flash/: flash.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/driver/led_light/: led_light.c
    ./: halPeripheral.c
  group profile
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/profiles/GATT/: gattservapp.c
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/components/profiles/ota_app/: ota_app_service.c
    ./source/: sbpProfile_ota.c
  group lib
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/lib/: rf.lib ble_host.lib
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/misc/: jump_table.c
  group simpleBlePeripheral
    ./source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c SimpleBLEPeripheral_Main.c driver_mpu9250.c driver_mpu9250_interface.c driver_mpu9250_basic.c i2c_soft_driver.c
  group misc
    ../../release_bbb_sdk-PHY62XX_SDK_3.1.5/misc/: bb_rom_sym_m0.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
